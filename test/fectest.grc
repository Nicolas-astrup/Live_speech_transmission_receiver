options:
  parameters:
    generate_options: qt_gui
    id: fectest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '1'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: length_tag
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '10'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '8192'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\haako\GIT\ELSYS-SEM2\RADIO\Live_speech_transmission_receiver\test\assets\citywok8.wav
    repeat: 'True'
  states: {}
- name: codec2488_0
  id: codec2488
  parameters:
    Decimate: '1'
    Interpolate: '1'
    packet_len: '6'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_extended_tagged_decoder_2
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: dec_cc
    lentagname: packet_len
    mtu: MTU
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_encoder_0_1
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: enc_cc
    lentagname: packet_len
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '6'
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: None
    name: ''
    size: '2000'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: None
    name: ''
    size: '2000'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.400'
    interp: '6'
    type: fff
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Decoded speech
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_2400
  states: {}

connections:
- [blocks_char_to_float_1_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_1_0_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_1_1, '0', fec_extended_tagged_decoder_2, '0']
- [blocks_repack_bits_bb_0, '0', fec_extended_tagged_encoder_0_1, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_wavfile_source_0, '0', codec2488_0, '0']
- [codec2488_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1_1, '0']
- [fec_extended_tagged_decoder_2, '0', blocks_char_to_float_1_0_0, '0']
- [fec_extended_tagged_decoder_2, '0', blocks_stream_to_vector_0, '0']
- [fec_extended_tagged_encoder_0_1, '0', blocks_char_to_float_1_0_0_0, '0']
- [fec_extended_tagged_encoder_0_1, '0', digital_map_bb_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
