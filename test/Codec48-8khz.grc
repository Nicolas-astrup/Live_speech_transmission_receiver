options:
  parameters:
    generate_options: hb
    id: codec2488
    output_language: python
    title: Codec2-48-8
  states: {}

blocks:
- name: Decimate
  id: parameter
  parameters:
    label: Decimate
    type: intx
    value: '1'
  states: {}
- name: Interpolate
  id: parameter
  parameters:
    label: interpolate
    type: intx
    value: '1'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: packet_len
  id: parameter
  parameters:
    label: Packet length Size (Byte)
    type: intx
    value: '6'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: Byte Stream out
    type: byte
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: 8KHZ(For compare)
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Voice in
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Decimate
    fbw: '0.400'
    interp: Interpolate
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_2400
  states: {}

connections:
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', pad_sink_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', pad_sink_2, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
