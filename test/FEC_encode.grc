options:
  parameters:
    generate_options: hb
    id: FEC_ENCODE
    output_language: python
    title: FEC encode
  states: {}

blocks:
- name: cc_encoder_def_1
  id: variable_cc_encoder_def
  parameters:
    framebits: '48'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'True'
    polys: '[171,133]'
    rate: '2'
    state_start: '0'
  states: {}
- name: Frame_bits
  id: parameter
  parameters:
    label: Frame bits
    value: '48'
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    value: '12'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: cc_encoder_def
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: fec_extended_tagged_encoder_0_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: cc_encoder_def
    lentagname: packet_len
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: packet_len
  id: parameter
  parameters:
    label: packet_len
    value: '"packet_len"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Byte out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Byte in
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0_1, '0', pad_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', fec_extended_tagged_encoder_0_0, '0']
- [fec_extended_tagged_encoder_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [pad_source_0, '0', blocks_repack_bits_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
