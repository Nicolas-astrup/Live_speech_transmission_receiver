options:
  parameters:
    author: Barry Duggan, modified by Gary Schafer
    category: Custom
    generate_options: qt_gui
    id: qpsk_modem
    output_language: python
    title: QPSK Modulator / Demodulator (modem)
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      This is used to align
      the transmitted and
      received bitstreams.
    gui_hint: 1,10,1,10
    label: Delay
    start: '0'
    step: '1'
    stop: '1000'
    value: '52'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    comment: |-
      Sets timing difference
      between transmitter
      and receiver due to
      variations in clocks.
    gui_hint: 0,10,1,10
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      This accounts for differences
      in local oscillators as well as
      static Doppler shift.
    gui_hint: 1,0,1,10
    label: 'Channel: Frequency Offset'
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: |-
      Sets noise level of added
      Gaussian white noise (AWGN)
      added during transmission
      as well as antenna noise and
      LNA of receiver.
    gui_hint: 0,0,1,10
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Symbol Map: [0,1,3,2] <- This is Gray coding
      Constellation Points: [-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '30000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\haako\OneDrive\Skrivebord\recived.bin
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Gray coding
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Symbol Rate: samp_rate/sps
      Alpha: excess_bw
      Num Taps: 11*sps
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {state: disabled}
- name: filter_fft_rrc_filter_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: Synced Only
    label2: Synced & Phase-Locked
    name: Synced Constellation
    nconnections: '2'
    size: '1024'
    type: complex
    width2: '2'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 12,0,10,20
    label1: Transmitted & Propagated
    label2: Received & Filtered
    name: Transmitted & Received Spectrum
    nconnections: '2'
    type: complex
    ymax: '-10'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,10,10,10
    label1: Recovered Data
    name: Demodulated Bitstream
    size: '100'
    srate: '1'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: '1000000'
    center_freq: '865000000'
    dev_args: driver=plutosdr
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: '1000000'
    center_freq: '865000000'
    dev_args: driver=plutosdr
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_signal
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decoded_signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: mod_signal
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_signal
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: decoded_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: t1
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_2, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0, '0', filter_fft_rrc_filter_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_3, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', soapy_plutosdr_sink_0, '0']
- [filter_fft_rrc_filter_0, '0', virtual_sink_0, '0']
- [filter_fft_rrc_filter_1, '0', digital_symbol_sync_xx_0, '0']
- [soapy_plutosdr_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_plutosdr_source_0, '0', filter_fft_rrc_filter_1, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
