options:
  parameters:
    author: haakon
    generate_options: hb
    id: Deinterleaver
    output_language: python
    title: Deinterleaver_self
  states: {}

blocks:
- name: Columns
  id: parameter
  parameters:
    label: Columns
    value: '20'
  states: {}
- name: Rows
  id: parameter
  parameters:
    label: Rows
    value: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet"'
    packet_len: '160'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '160'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '160'
    type: byte
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, rows=8, cols=20):
              self.rows = rows
              self.cols = cols
              self.N = rows * cols

              gr.sync_block.__init__(
                  self,
                  name="bit_deinterleaver_160",
                  in_sig=[(np.uint8, self.N)],
                  out_sig=[(np.uint8, self.N)]
              )

          def work(self, input_items, output_items):
              inv = input_items[0]
              outv = output_items[0]

              for i in range(len(inv)):
                  frame = np.array(inv[i], copy=False).reshape((self.cols, self.rows))
                  outv[i][:] = frame.T.reshape(self.N)

              return len(outv)
    cols: Columns
    rows: Rows
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Bit out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Bit in
    type: byte
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', pad_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_1, '0', blocks_vector_to_stream_1_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
