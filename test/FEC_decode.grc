options:
  parameters:
    generate_options: hb
    id: FEC_decoder
    output_language: python
    title: FEC Decoder
  states: {}

blocks:
- name: cc_decoder_def_1
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '1'
    padding: 'True'
    polys: '[171,133]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    value: '12'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: cc_decoder_def
  id: parameter
  parameters:
    label: CC_decoder
    value: '0'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_extended_tagged_decoder_0_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: cc_decoder_def
    lentagname: packet_len
    mtu: MTU
    puncpat: '''11'''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Bitstream out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Bitstream in
    type: byte
  states: {}

connections:
- [blocks_char_to_float_1, '0', fec_extended_tagged_decoder_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1, '0']
- [fec_extended_tagged_decoder_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', digital_map_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
