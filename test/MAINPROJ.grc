options:
  parameters:
    author: haako
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: QT_gain
  id: variable_qtgui_range
  parameters:
    label: RX_gain
    start: '0'
    step: '1'
    stop: '73'
    value: '10'
    widget: eng_slider
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '865000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: CRC32_header_0
  id: CRC32_header
  parameters:
    payload_size: '48'
    postamble_size: '64'
    preamble_size: '384'
    samp_rate: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '1'
    num_samps: '50'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\haako\OneDrive\Skrivebord\poo.bin.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\haako\OneDrive\Skrivebord\piss.bin
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '8192'
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '6'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: codec2488_0
  id: codec2488
  parameters:
    Decimate: '6'
    Interpolate: '1'
    packet_len: '6'
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: '0.01'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(constel.points())
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '0.707'
    loop_bw: '0.01'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: filter_fft_rrc_filter_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '88'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    label1: Synced Only
    label2: Synced & Phase-Locked
    name: Synced Constellation
    nconnections: '2'
    size: '1024'
    type: complex
    width2: '2'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[2, 0, 2, 1]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[4, 0, 2, 1]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Real
    name: goo goo Symbols
    size: '200'
    srate: samp_rate/sps
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.1'
    ymax: '255'
    ymin: '0'
    yunit: '"gooo gooo"'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.400'
    interp: '6'
    type: fff
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: '1000000'
    center_freq: frequency
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: '1000000'
    center_freq: frequency
    gain: QT_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: CRC_appended
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Decoded speech
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: gabagoo
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: CRC_appended
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: gabagoo
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_2400
  states: {}

connections:
- [CRC32_header_0, '0', blocks_file_sink_0, '0']
- [CRC32_header_0, '0', virtual_sink_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [audio_source_0, '0', codec2488_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', filter_fft_rrc_filter_1, '0']
- [blocks_repack_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', CRC32_header_0, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [codec2488_0, '0', CRC32_header_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_file_sink_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_crc32_bb_1, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_3, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [filter_fft_rrc_filter_1, '0', soapy_plutosdr_sink_0, '0']
- [filter_fft_rrc_filter_1, '0', virtual_sink_5, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_plutosdr_source_0, '0', filter_fft_rrc_filter_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_2, '0', blocks_char_to_float_0, '0']
- [virtual_source_2, '0', blocks_repack_bits_bb_0, '0']
- [virtual_source_3, '0', blocks_repack_bits_bb_1, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
