options:
  parameters:
    author: Frank Fu, Barry Duggan
    generate_options: qt_gui
    id: bpsk_file_transfer_loopback2_Pluto
    output_language: python
    title: bpsk_file_transfer_loopback2_Pluto
  states: {}

blocks:
- name: FEC_frameBits
  id: variable
  parameters:
    value: '80'
  states: {}
- name: QT_gain
  id: variable_qtgui_range
  parameters:
    label: RX_gain
    start: '0'
    step: '1'
    stop: '73'
    value: '50'
    widget: eng_slider
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: costas_bw
  id: variable_qtgui_range
  parameters:
    label: costas loop bw
    start: '0.01'
    step: '0.01'
    stop: '0.08'
    value: '0.06'
  states: {}
- name: data
  id: variable_qtgui_label
  parameters:
    label: data
    type: int
    value: '0'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'True'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable_qtgui_range
  parameters:
    label: excess bw-constelmodulator
    start: '0.1'
    step: '0.05'
    stop: '0.6'
    value: '0.35'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '865200000'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: leght
  id: variable
  parameters:
    value: '47'
  states: {}
- name: mod_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble_gold
    mod: rxmod
    taps: '[1]'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '180'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109,79]'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: preamble_gold
  id: variable
  parameters:
    value: '[0x55,0xAA]'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    comment: |-
      Symbol Map: [0,1,3,2] <- This is Gray coding
      Constellation Points: [-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_on
  id: variable
  parameters:
    value: 1-tx_on
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(qpsk, True, sps, True, excess_bw, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sym_bw
  id: variable_qtgui_range
  parameters:
    label: symbol loop bw
    start: '0.02'
    step: '0.001'
    stop: '0.12'
    value: '0.088'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'NOTE: attenuation!'
    label: Tx gain
    start: '0'
    step: '1'
    stop: '89'
    value: '89'
  states: {}
- name: tx_on
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: TX/RX switch
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: tx_on
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: tx/rx button
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: Deinterleaver_0
  id: Deinterleaver
  parameters:
    Columns: '8'
    Rows: '20'
  states: {}
- name: FEC_ENCODE_0
  id: FEC_ENCODE
  parameters:
    Frame_bits: frame_size
    MTU: MTU
    cc_encoder_def: enc_cc
    packet_len: '"packet_len"'
  states: {}
- name: FEC_decoder_0
  id: FEC_decoder
  parameters:
    MTU: MTU
    cc_decoder_def: dec_cc
  states: {}
- name: Interleaver_simple_0
  id: Interleaver_simple
  parameters:
    Columns: '8'
    Rows: '20'
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '18'
  states: {}
- name: PER
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"PER"'
    type: float
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-tx_on
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_on
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '8192'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet"'
    packet_len: '640'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: preamble_gold
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\haako\GIT\ELSYS-SEM2\RADIO\Live_speech_transmission_receiver\test\assets\citywok8.wav
    repeat: 'True'
  states: {state: disabled}
- name: codec2488_0
  id: codec2488
  parameters:
    Decimate: '6'
    Interpolate: '1'
    packet_len: '6'
  states: {}
- name: digital_additive_scrambler_xx_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: '"packet_len"'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: sps
    sps: sps
    symbols: mod_sync_word
    threshold: '0.7'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Gray coding
    map: '[0,1,3,2]'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '0.707'
    loop_bw: sym_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.707'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, packet_len=160, cols=16):
              gr.sync_block.__init__(
                  self,
                  name='Deinterleaver',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.packet_len = packet_len
              self.cols = cols
              self.rows = packet_len // cols
              self.buffer = []
              self.copying = False
              self.remaining = 0
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n_produced = 0

              tags = self.get_tags_in_window(0, 0, len(in0))
              for tag in tags:
                  if pmt.to_python(tag.key) == 'packet_len':
                      self.copying = True
                      self.remaining = pmt.to_python(tag.value)
                      self.buffer = []

              for i, byte in enumerate(in0):
                  if self.copying and self.remaining > 0:
                      self.buffer.append(byte)
                      self.remaining -= 1

                      if self.remaining == 0:
                          packet = np.array(self.buffer, dtype=np.uint8)
                          matrix = packet.reshape(self.cols, self.rows)
                          deinterleaved = matrix.T.flatten()

                          out[n_produced:n_produced + self.packet_len] = deinterleaved

                          self.add_item_tag(
                              0,
                              self.nitems_written(0) + n_produced,
                              pmt.intern('packet_len'),
                              pmt.from_long(self.packet_len)
                          )

                          n_produced += self.packet_len
                          self.copying = False
                          self.buffer = []

              return n_produced
    cols: '8'
    packet_len: '160'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, packet_size=6):
              gr.sync_block.__init__(
                  self,
                  name="RX Byte Counter",
                  in_sig=[np.uint8],
                  out_sig=[np.float32]
              )

              self.total_bytes = 0
              self.packet_size = packet_size

          def work(self, input_items, output_items):
              n = len(input_items[0])
              out = output_items[0]

              self.total_bytes += n

              # choose one:
              value = self.total_bytes   / 6            # bytes
              # value = self.total_bytes / self.packet_size   # packets

              out[:] = float(value)

              return n
    packet_size: '6'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, packet_size=6):
              gr.sync_block.__init__(
                  self,
                  name="RX Byte Counter",
                  in_sig=[np.uint8],
                  out_sig=[np.float32]
              )

              self.total_bytes = 0
              self.packet_size = packet_size

          def work(self, input_items, output_items):
              n = len(input_items[0])
              out = output_items[0]

              self.total_bytes += n

              # choose one:
              value = self.total_bytes   / 6            # bytes
              # value = self.total_bytes / self.packet_size   # packets

              out[:] = float(value)

              return n
    packet_size: '10'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, window_bytes=600):
              gr.sync_block.__init__(
                  self,
                  name="PER Window Bytes (FEC in0, CRC in1)",
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )

              self.window_bytes = int(window_bytes)

              self.prev_fec_bytes = 0
              self.prev_crc_bytes = 0

              self.win_fec_bytes = 0
              self.win_crc_bytes = 0

              self.per = 0.0

          def work(self, input_items, output_items):
              fec_now = int(input_items[0][-1])   # input 0 = FEC bytes
              crc_now = int(input_items[1][-1])   # input 1 = CRC good bytes
              out = output_items[0]

              dfec = fec_now - self.prev_fec_bytes
              dcrc = crc_now - self.prev_crc_bytes

              self.prev_fec_bytes = fec_now
              self.prev_crc_bytes = crc_now

              if dfec < 0: dfec = 0
              if dcrc < 0: dcrc = 0

              self.win_fec_bytes += dfec
              self.win_crc_bytes += dcrc

              if self.win_fec_bytes >= self.window_bytes:
                  failed = self.win_fec_bytes - self.win_crc_bytes
                  if failed < 0:
                      failed = 0

                  self.per = failed / float(self.win_fec_bytes)

                  self.win_fec_bytes = 0
                  self.win_crc_bytes = 0

              out[:] = self.per
              return len(out)
    window_bytes: '100'
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: filter_fft_rrc_filter_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: '88'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {state: disabled}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '6'
  states: {}
- name: nmrpcts
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Number of packets"'
    type: float
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    label1: Synced Only
    label2: Synced & Phase-Locked
    name: Synced Constellation
    nconnections: '2'
    size: '2048'
    type: complex
    update_time: '0.20'
    width2: '2'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmit data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[2, 0, 2, 1]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: '[4, 0, 2, 1]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Real
    name: goo goo Symbols
    size: '200'
    srate: samp_rate/sps
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.1'
    ymax: '255'
    ymin: '0'
    yunit: '"gooo gooo"'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Real
    name: after interleaver
    size: '200'
    srate: samp_rate/sps
    tr_delay: '0.0'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.1'
    ymax: '255'
    ymin: '0'
    yunit: '"gooo gooo"'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/100
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.400'
    interp: '6'
    type: fff
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: samp_rate/sps*2
    center_freq: frequency
    gain: tx_gain*tx_on
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: 'True'
    bandwidth: samp_rate/sps*2
    center_freq: frequency
    gain: QT_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mod_sink
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Decoded speech
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mod_sink
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_2400
  states: {}

connections:
- [Deinterleaver_0, '0', FEC_decoder_0, '0']
- [Deinterleaver_0, '0', blocks_char_to_float_0_0, '0']
- [FEC_ENCODE_0, '0', digital_protocol_formatter_bb_0, '0']
- [FEC_ENCODE_0, '0', virtual_sink_2_0, '0']
- [FEC_decoder_0, '0', blocks_repack_bits_bb_1, '0']
- [Interleaver_simple_0, '0', blocks_tagged_stream_mux_0, '2']
- [audio_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', filter_fft_rrc_filter_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', filter_fft_rrc_filter_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', soapy_plutosdr_sink_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', codec2488_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_additive_scrambler_xx_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_repack_bits_bb_1, '0', epy_block_0_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_additive_scrambler_xx_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', codec2488_0, '0']
- [codec2488_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_additive_scrambler_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [digital_additive_scrambler_xx_0_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_corr_est_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', FEC_ENCODE_0, '0']
- [digital_crc32_bb_1, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [epy_block_0, '0', FEC_decoder_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0_0, '0']
- [epy_block_0_0, '0', epy_block_1, '1']
- [epy_block_0_0, '0', nmrpcts, '0']
- [epy_block_0_0_0, '0', epy_block_1, '0']
- [epy_block_1, '0', PER, '0']
- [filter_fft_rrc_filter_0, '0', digital_corr_est_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [filter_fft_rrc_filter_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [filter_fft_rrc_filter_1, '0', blocks_tag_debug_0, '0']
- [filter_fft_rrc_filter_1, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_3, '0', Deinterleaver_0, '0']
- [virtual_source_3, '0', epy_block_0, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_6, '0', Interleaver_simple_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
