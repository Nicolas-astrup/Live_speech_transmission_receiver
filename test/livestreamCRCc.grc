options:
  parameters:
    generate_options: qt_gui
    id: livestreammic
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CC_DEC
  id: variable_cc_decoder_def
  parameters:
    framebits: '48'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[171,133]'
    rate: '2'
    state_end: '0'
    state_start: '0'
  states: {}
- name: CC_ENC
  id: variable_cc_encoder_def
  parameters:
    framebits: '48'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[171,133]'
    rate: '2'
    state_start: '0'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''11001001011101101000101110110101'''
  states: {state: disabled}
- name: corr_access_key
  id: variable
  parameters:
    value: '''10010011011011101101000110101101'''
  states: {}
- name: header_frmt
  id: variable
  parameters:
    value: digital.header_format_default(corr_access_key, 0)
  states: {}
- name: loop_bandwith
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_RRC
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: PDU_16_bit_append_0
  id: PDU_16_bit_append
  parameters: {}
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '1'
    num_samps: '50'
    repeat: 'False'
    type: byte
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\haako\OneDrive\Skrivebord\piss.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\haako\OneDrive\Skrivebord\poo.bin.bin
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_1_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '8192'
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '6'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    single_key: '"ccc"'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: codec2488_0
  id: codec2488
  parameters:
    Decimate: '1'
    Interpolate: '1'
    packet_len: '6'
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: corr_access_key
    tagname: '"ccc"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header_frmt
    len_tag_key: '"packet_len"'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: CC_DEC
    puncpat: '''11'''
    threadtype: none
  states: {state: disabled}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: CC_ENC
    puncpat: '''11'''
    threadtype: capillary
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: PAIN, PASS PÅ AT FEC DECODER FÅR SOFT DECISION FLOATS IKKE BITS
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '8000'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"fec decodec"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"aaa"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {state: disabled}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0'
    initial_value: '0x0'
    num_bits: '16'
    poly: '0x1021'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: raw audio
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: crc_encoded
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Decoded speech
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: FEC_encoded
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: fec_decoded
  states: {state: disabled}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: access_found
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: access_found
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: raw audio
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Decoded speech
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: crc_encoded
  states: {state: disabled}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: FEC_encoded
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: crc_encoded
  states: {state: disabled}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_2400
  states: {}

connections:
- [PDU_16_bit_append_0, '0', blocks_file_sink_0, '0']
- [PDU_16_bit_append_0, '1', virtual_sink_0_0, '0']
- [PDU_16_bit_append_0, PDU, blocks_message_debug_0_0, print]
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [audio_source_0, '0', codec2488_0, '0']
- [blocks_add_const_vxx_0, '0', fec_extended_decoder_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_repack_bits_bb_0_1_0, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_0_1_0, '0', blocks_tag_debug_1, '0']
- [blocks_repack_bits_bb_0_1_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_repack_bits_bb_0_1_1, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_repack_bits_bb_0_1_1, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', PDU_16_bit_append_0, '0']
- [blocks_stream_to_vector_0, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_4, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [codec2488_0, '0', PDU_16_bit_append_0, '0']
- [codec2488_0, '1', qtgui_time_sink_x_0_0, '0']
- [codec2488_0, '1', virtual_sink_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_gate_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_extended_decoder_0, '0', virtual_sink_3, '0']
- [fec_extended_encoder_0, '0', virtual_sink_2, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, satellites_crc_check_0, in]
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [satellites_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', blocks_repack_bits_bb_0_1_0, '0']
- [virtual_source_0, '0', blocks_tag_debug_1_0, '0']
- [virtual_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_2, '0', fec_extended_encoder_0, '0']
- [virtual_source_3, '0', blocks_uchar_to_float_0, '0']
- [virtual_source_4, '0', blocks_repack_bits_bb_0_1_1, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
